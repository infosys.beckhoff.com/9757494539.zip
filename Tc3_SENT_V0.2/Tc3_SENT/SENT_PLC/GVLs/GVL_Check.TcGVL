{attribute 'qualified_only'}
VAR_GLOBAL
	nCntLower		: UINT;
	nCntUpper		: UINT;
END_VAR
