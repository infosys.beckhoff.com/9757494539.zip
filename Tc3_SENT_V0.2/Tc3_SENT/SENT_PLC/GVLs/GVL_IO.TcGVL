{attribute 'qualified_only'}
VAR_GLOBAL
	nEl1262Ch1		AT%I*	: ARRAY[1..125] OF BYTE;
	nEl1262Ch2		AT%I*	: ARRAY[1..125] OF BYTE;
END_VAR
