{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_SentSlowChnConfig :
(
	eShortSerial := 1,
	eEnhancedSerial
	
);
END_TYPE
