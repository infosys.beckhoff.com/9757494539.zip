TYPE ST_SentFastChnData :
STRUCT
	nStatus		: USINT;
	nValue1		: UINT;
	nValue2		: UINT;
	nMsgCnt		: USINT;
	nInvMsnV1	: USINT;
	nCrc		: USINT;
	
END_STRUCT
END_TYPE
