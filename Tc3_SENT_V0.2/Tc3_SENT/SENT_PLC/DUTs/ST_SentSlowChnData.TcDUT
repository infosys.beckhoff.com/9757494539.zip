TYPE ST_SentSlowChnData :
STRUCT
	nMsgId			: USINT;
	nData			: UINT;
	nCrc			: USINT;
END_STRUCT
END_TYPE
